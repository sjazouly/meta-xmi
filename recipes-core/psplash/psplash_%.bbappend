FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGES:forcevariable = "file://future-logo_800.png;outsuffix=default"
