FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
   	file://0001-update-uname-value-to-work-with-fdc-mamabear-board-n.patch \
   "
