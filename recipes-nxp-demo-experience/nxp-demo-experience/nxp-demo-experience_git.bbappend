FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
   	file://0001-change-default-machine-from-7ULP-to-8MPlus-so-that-t.patch \
   "


