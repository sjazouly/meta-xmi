FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-add-in-driver-for-AR0830-from-On-Semi.patch "
