FILESEXTRAPATHS:prepend := "{THISDIR}/files:"
SOURCE_URI += "file://0001-add-in-support-for-On-Semi-AR0830-sensor.patch"
